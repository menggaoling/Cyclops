# IAR project Cyclops.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; Modules\STM32_Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; Modules\STM32_Lib\STM32F10x_StdPeriph_Driver\inc; Modules\STM32_Lib; APP; Modules\HAL_Lib; Modules\Csafe_Lib; Modules\LCB_Lib; Modules\MyeTV_Lib; Modules\RFID_Lib; Modules\UCB_Lib; Modules\Timer_Lib; Modules\Machine_Lib; Modules\Program_Lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Cyclops.srec
  ILINK.IlinkOutputFile: Cyclops.out
  ILINK.IlinkIcfFile: stm32f105xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/: main.c
  group Modules/Csafe_Lib
    Modules/Csafe_Lib/: C_safe.c
  group Modules/FAN_Lib
    Modules/FAN_Lib/: Fan.c
  group Modules/HAL_Lib
    Modules/HAL_Lib/: HAL_BSP.c HAL_Interface.c
  group Modules/LCB_Lib
    Modules/LCB_Lib/: Digital.c LCB.c LCB_Support.c
  group Modules/Machine_Lib
    Modules/Machine_Lib/: Treadmill.c
  group Modules/MyeTV_Lib
    Modules/MyeTV_Lib/: TV.c
  group Modules/Program_Lib
    Modules/Program_Lib/: Formula.c
  group Modules/RFID_Lib
    Modules/RFID_Lib/: RFID_GATRM310.c
  group Modules/STM32_Lib
    Modules/STM32_Lib/: stm32f10x_it.c
  group Modules/STM32_Lib/CMSIS
    Modules/STM32_Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    Modules/STM32_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    Modules/STM32_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Modules/STM32_Lib/Driver_Lib
    Modules/STM32_Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Modules/Timer_Lib
    Modules/Timer_Lib/: Timer.c
  group Modules/UCB_Lib
    Modules/UCB_Lib/: Communication.c
